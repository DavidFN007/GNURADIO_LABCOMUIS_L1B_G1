options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: x
    output_language: python
    title: x
  states: {}

blocks:
- name: d1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: fs
  id: variable
  parameters:
    value: samp_rate/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e5
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: Ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: Lab5_0
  id: Lab5
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Lab5_0_1
  id: Lab5
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Lab5_0, '0', qtgui_freq_sink_x_0, '0']
- [Lab5_0, '0', qtgui_time_sink_x_0, '0']
- [Lab5_0_1, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0, '0', Lab5_0, '0']
- [analog_sig_source_x_0_0, '0', Lab5_0_1, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
